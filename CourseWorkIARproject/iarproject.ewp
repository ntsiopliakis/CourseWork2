# IAR project iarproject.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411RE ST STM32F411RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: Rtos; Rtos\wrapper; Rtos\wrapper\FreeRtos; Rtos\FreeRtos; Rtos\FreeRtos\include; Rtos\FreeRtos\portable; Rtos\FreeRtos\portable\Common; Rtos\FreeRtos\portable\IAR; Rtos\FreeRtos\portable\IAR\ARM_CM4F; Rtos\FreeRtos\portable\MemMang; MyTasks; CMSIS; Application; Application\Diagnostic; AHardware; AHardware\GpioPort; AHardware\IrqController; AHardware\Registers\STM32F411\FieldValues; AHardware\Registers\STM32F411; AHardware\Registers; AHardware\Atomic; Common; Common\Singleton; Common\RomObject; AHardware\Port; AHardware\Pin; Application\Button; Application\Led; Application\Measurement; AHardware\USART; AHardware\Registers\CortexM4; AHardware\Registers\CortexM4\FieldValues; AHardware\SPI; AHardware\BME280Driver; AHardware\EPDDriver; Application\GUI; Application\GUI\Fonts; Application\Display
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: Rtos; Rtos\FreeRtos; Rtos\FreeRtos\include; Rtos\FreeRtos\portable\IAR; Rtos\FreeRtos\portable\IAR\ARM_CM4F; Rtos\wrapper\FreeRtos; Rtos\wrapper
  OBJCOPY.OOCOutputFile: iarproject.srec
  ILINK.IlinkOutputFile: iarproject.out
  ILINK.IlinkIcfFile: stm32f411xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group (top)
    ./: main.cpp startupF411RE.cpp
  group AHardware/BME280Driver
    AHardware/BME280Driver/: BME280Driver.h bme280driverconfig.h
  group AHardware/BME280Driver/EPDDriver
    AHardware/EPDDriver/: epddriver.h epddriverconfig.h
  group AHardware/IrqController
    AHardware/IrqController/: irqcontroller.cpp irqcontroller.hpp
  group AHardware/Pin
    AHardware/Pin/: pin.h pinsconfig.h
  group AHardware/Port
    AHardware/Port/: port.h portsconfig.h
  group AHardware/SPI
    AHardware/SPI/: spi.h spiconfig.h spiDriver.h
  group AHardware/USART
    AHardware/USART/: usart.h usartconfig.h usartDriver.h
  group Application/Button
    Application/Button/: Button.h buttonsconfig.h
  group Application/Display
    Application/Display/: display.h
  group Application/GUI
    Application/GUI/: ScreenDriver.h ScreenWallPapers.h
  group Application/GUI/Fonts
    Application/GUI/Fonts/: font.h font.hpp font24.cpp font48.cpp font_segoeUISemibold_24pt.h font_segoeUISemibold_48pt.h segoeUISemibold_24pt.h
  group Application/Led
    Application/Led/: led.h ledsconfig.h
  group Application/Measurement
    Application/Measurement/: Measurement.h measurementconfig.h Temperature.h
  group MyTasks
    MyTasks/: BluetoothTask.h ButtonEventTask.h DisplayUpdateTask.h MeasurementTask.h
  group Rtos/FreeRtos
    Rtos/FreeRtos/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Rtos/FreeRtos/portable/Common
    Rtos/FreeRtos/portable/Common/: mpu_wrappers.c
  group Rtos/FreeRtos/portable/IAR/ARM_CM4F
    Rtos/FreeRtos/portable/IAR/ARM_CM4F/: port.c portasm.c portasm.s
  group Rtos/FreeRtos/portable/MemMang
    Rtos/FreeRtos/portable/MemMang/: heap_1.c
  group Rtos/wrapper
    Rtos/wrapper/: criticalsection.hpp event.hpp eventmode.hpp interruptentry.hpp mailbox.hpp mutex.hpp rtos.hpp thread.hpp
